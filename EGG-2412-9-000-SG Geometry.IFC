Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Geometry\EGG-2412-9-000-SG Geometry.IFC
Time: 2024-11-05T12:16:03+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 28.2200954184932726; Volume Measure: 0.0282200954184935; Area Measure: 13.6419456413497127

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 28.2200954184932726; Volume Measure: 0.0282200954184935; Area Measure: 13.6419456413497127

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 28.2200954184932726; Volume Measure: 0.0282200954184935; Area Measure: 13.6419456413497127

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGG-2412-9-000-SG Geometry | PSet_Mass_Property - Mass Measure: 28.2200954184932726; Volume Measure: 0.0282200954184935; Area Measure: 13.6419456413497127
EGG-2412-9-000-SG Geometry | SOLIDWORKS Custom Properties - Description: GEOMETRY; PartNo: EGG-2412-9-000-SG; Revision: A; Material: 9MM EKKO ACOUSTIC PANEL; Finish: 6MM WIDE X 3MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
