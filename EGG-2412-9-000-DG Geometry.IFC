Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Geometry\EGG-2412-9-000-DG Geometry.IFC
Time: 2024-11-05T12:16:18+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 29.5558535127619422; Volume Measure: 0.0295558535127618; Area Measure: 13.8118276843711634

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 29.5558535127619422; Volume Measure: 0.0295558535127618; Area Measure: 13.8118276843711634

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 29.5558535127619422; Volume Measure: 0.0295558535127618; Area Measure: 13.8118276843711634

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGG-2412-9-000-DG Geometry | PSet_Mass_Property - Mass Measure: 29.5558535127619422; Volume Measure: 0.0295558535127618; Area Measure: 13.8118276843711634
EGG-2412-9-000-DG Geometry | SOLIDWORKS Custom Properties - Description: GEOMETRY; PartNo: EGG-2412-9-000-DG; Revision: A; Material: 9MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
