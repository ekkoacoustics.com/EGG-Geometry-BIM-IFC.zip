Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Geometry\EGG-2412-12-000-DG Geometry.IFC
Time: 2024-11-05T12:15:50+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 38.1958535127618504; Volume Measure: 0.0381958535127619; Area Measure: 13.8334276843711628

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 38.1958535127618504; Volume Measure: 0.0381958535127619; Area Measure: 13.8334276843711628

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 38.1958535127618504; Volume Measure: 0.0381958535127619; Area Measure: 13.8334276843711628

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGG-2412-12-000-DG Geometry | PSet_Mass_Property - Mass Measure: 38.1958535127618504; Volume Measure: 0.0381958535127619; Area Measure: 13.8334276843711628
EGG-2412-12-000-DG Geometry | SOLIDWORKS Custom Properties - Description: GEOMETRY; PartNo: EGG-2412-12-000-DG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
